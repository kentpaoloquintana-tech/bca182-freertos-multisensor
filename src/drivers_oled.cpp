#include "stm32f1xx_hal.h"

#include "drivers_oled.h"
#include "drivers_sensors.h"

#include <string.h>

namespace {

const uint8_t kOledAddress = 0x3C;
uint8_t oledBuffer[128U * 64U / 8U];

const uint8_t font5x7[][5] = {
    {0x00,0x00,0x00,0x00,0x00}, {0x00,0x00,0x5F,0x00,0x00},
    {0x00,0x07,0x00,0x07,0x00}, {0x14,0x7F,0x14,0x7F,0x14},
    {0x24,0x2A,0x7F,0x2A,0x12}, {0x23,0x13,0x08,0x64,0x62},
    {0x36,0x49,0x55,0x22,0x50}, {0x00,0x05,0x03,0x00,0x00},
    {0x00,0x1C,0x22,0x41,0x00}, {0x00,0x41,0x22,0x1C,0x00},
    {0x14,0x08,0x3E,0x08,0x14}, {0x08,0x08,0x3E,0x08,0x08},
    {0x00,0x50,0x30,0x00,0x00}, {0x08,0x08,0x08,0x08,0x08},
    {0x00,0x60,0x60,0x00,0x00}, {0x20,0x10,0x08,0x04,0x02},
    {0x3E,0x51,0x49,0x45,0x3E}, {0x00,0x42,0x7F,0x40,0x00},
    {0x42,0x61,0x51,0x49,0x46}, {0x21,0x41,0x45,0x4B,0x31},
    {0x18,0x14,0x12,0x7F,0x10}, {0x27,0x45,0x45,0x45,0x39},
    {0x3C,0x4A,0x49,0x49,0x30}, {0x01,0x71,0x09,0x05,0x03},
    {0x36,0x49,0x49,0x49,0x36}, {0x06,0x49,0x49,0x29,0x1E},
    {0x00,0x36,0x36,0x00,0x00}, {0x00,0x56,0x36,0x00,0x00},
    {0x08,0x14,0x22,0x41,0x00}, {0x14,0x14,0x14,0x14,0x14},
    {0x00,0x41,0x22,0x14,0x08}, {0x02,0x01,0x51,0x09,0x06},
    {0x32,0x49,0x79,0x41,0x3E}, {0x7E,0x11,0x11,0x11,0x7E},
    {0x7F,0x49,0x49,0x49,0x36}, {0x3E,0x41,0x41,0x41,0x22},
    {0x7F,0x41,0x41,0x22,0x1C}, {0x7F,0x49,0x49,0x49,0x41},
    {0x7F,0x09,0x09,0x09,0x01}, {0x3E,0x41,0x49,0x49,0x7A},
    {0x7F,0x08,0x08,0x08,0x7F}, {0x00,0x41,0x7F,0x41,0x00},
    {0x20,0x40,0x41,0x3F,0x01}, {0x7F,0x08,0x14,0x22,0x41},
    {0x7F,0x40,0x40,0x40,0x40}, {0x7F,0x02,0x0C,0x02,0x7F},
    {0x7F,0x04,0x08,0x10,0x7F}, {0x3E,0x41,0x41,0x41,0x3E},
    {0x7F,0x09,0x09,0x09,0x06}, {0x3E,0x41,0x51,0x21,0x5E},
    {0x7F,0x09,0x19,0x29,0x46}, {0x46,0x49,0x49,0x49,0x31},
    {0x01,0x01,0x7F,0x01,0x01}, {0x3F,0x40,0x40,0x40,0x3F},
    {0x1F,0x20,0x40,0x20,0x1F}, {0x3F,0x40,0x38,0x40,0x3F},
    {0x63,0x14,0x08,0x14,0x63}, {0x07,0x08,0x70,0x08,0x07},
    {0x61,0x51,0x49,0x45,0x43}
};

const uint8_t fontBracketSymbols[][5] = {
    {0x00,0x7F,0x41,0x41,0x00}, {0x02,0x04,0x08,0x10,0x20},
    {0x00,0x41,0x41,0x7F,0x00}, {0x04,0x02,0x01,0x02,0x04},
    {0x40,0x40,0x40,0x40,0x40}, {0x00,0x01,0x02,0x04,0x00}
};

const uint8_t fontBraceSymbols[][5] = {
    {0x00,0x08,0x36,0x41,0x00}, {0x00,0x00,0x7F,0x00,0x00},
    {0x00,0x41,0x36,0x08,0x00}, {0x08,0x04,0x08,0x10,0x08}
};

inline void SCL(bool high)
{
    HAL_GPIO_WritePin(GPIOB, GPIO_PIN_6, high ? GPIO_PIN_SET : GPIO_PIN_RESET);
    __NOP();
    __NOP();
}

inline void SDA(bool high)
{
    HAL_GPIO_WritePin(GPIOB, GPIO_PIN_7, high ? GPIO_PIN_SET : GPIO_PIN_RESET);
    __NOP();
    __NOP();
}

void I2C_Start(void)
{
    SDA(true);
    SCL(true);
    SDA(false);
    SCL(false);
}

void I2C_Stop(void)
{
    SDA(false);
    SCL(true);
    SDA(true);
}

void I2C_WriteByte(uint8_t value)
{
    for (uint8_t bit = 0; bit < 8; ++bit) {
        SDA((value & 0x80U) != 0U);
        value <<= 1U;
        SCL(true);
        SCL(false);
    }
    SDA(true);
    SCL(true);
    SCL(false);
}

void OLED_WriteCommands(const uint8_t *commands, uint8_t count)
{
    I2C_Start();
    I2C_WriteByte(static_cast<uint8_t>(kOledAddress << 1U));
    I2C_WriteByte(0x00);
    for (uint8_t i = 0; i < count; ++i) {
        I2C_WriteByte(commands[i]);
    }
    I2C_Stop();
}

void OLED_WriteData(const uint8_t *data, uint8_t count)
{
    I2C_Start();
    I2C_WriteByte(static_cast<uint8_t>(kOledAddress << 1U));
    I2C_WriteByte(0x40);
    for (uint8_t i = 0; i < count; ++i) {
        I2C_WriteByte(data[i]);
    }
    I2C_Stop();
}

void AppendText(char *out, int &index, const char *text)
{
    while (*text != '\0') {
        out[index++] = *text++;
    }
}

}

void OLED_Init(void)
{
    __HAL_RCC_GPIOB_CLK_ENABLE();
    GPIO_InitTypeDef gpio = {};
    gpio.Pin = GPIO_PIN_6 | GPIO_PIN_7;
    gpio.Mode = GPIO_MODE_OUTPUT_OD;
    gpio.Pull = GPIO_PULLUP;
    gpio.Speed = GPIO_SPEED_FREQ_HIGH;
    HAL_GPIO_Init(GPIOB, &gpio);
    HAL_GPIO_WritePin(GPIOB, GPIO_PIN_6 | GPIO_PIN_7, GPIO_PIN_SET);

    const uint8_t initSequence[] = {
        0xAE, 0x20, 0x02, 0xB0, 0xC8, 0x00, 0x10, 0x40, 0x81, 0xFF,
        0xA1, 0xA6, 0xA8, 0x3F, 0xA4, 0xD3, 0x00, 0xD5, 0xF0, 0xD9,
        0x22, 0xDA, 0x12, 0xDB, 0x20, 0x8D, 0x14, 0xAF
    };
    OLED_WriteCommands(initSequence, sizeof(initSequence));
    OLED_Clear();
    OLED_Update();
}

void OLED_SetDisplay(bool enabled)
{
    const uint8_t command = enabled ? 0xAFU : 0xAEU;
    OLED_WriteCommands(&command, 1U);
}

void OLED_Clear(void)
{
    memset(oledBuffer, 0, sizeof(oledBuffer));
}

void OLED_DrawString(uint8_t x, uint8_t page, const char *text)
{
    if (page >= 8U || text == NULL) {
        return;
    }
    while (*text != '\0' && x <= 122U) {
        char character = *text++;
        if (character >= 'a' && character <= 'z') {
            character = static_cast<char>(character - 'a' + 'A');
        }
        const uint8_t *glyph;
        if (character >= ' ' && character <= 'Z') {
            glyph = font5x7[character - ' '];
        } else if (character >= '[' && character <= '`') {
            glyph = fontBracketSymbols[character - '['];
        } else if (character >= '{' && character <= '~') {
            glyph = fontBraceSymbols[character - '{'];
        } else {
            glyph = font5x7[0];
        }
        for (uint8_t column = 0; column < 5U; ++column) {
            oledBuffer[page * 128U + x + column] = glyph[column];
        }
        oledBuffer[page * 128U + x + 5U] = 0;
        x += 6U;
    }
}

void OLED_Update(void)
{
    for (uint8_t page = 0; page < 8U; ++page) {
        const uint8_t pageCommands[] = {
            static_cast<uint8_t>(0xB0U + page), 0x00, 0x10
        };
        OLED_WriteCommands(pageCommands, sizeof(pageCommands));
        OLED_WriteData(&oledBuffer[page * 128U], 128);
    }
}

void Format_Fixed1(char *out, const char *prefix, float value, const char *suffix)
{
    int index = 0;
    AppendText(out, index, prefix);
    if (value < 0.0f) {
        out[index++] = '-';
        value = -value;
    }
    const int tenths = static_cast<int>(value * 10.0f + 0.5f);
    const int whole = tenths / 10;
    if (whole >= 100) {
        out[index++] = static_cast<char>('0' + (whole / 100) % 10);
    }
    if (whole >= 10) {
        out[index++] = static_cast<char>('0' + (whole / 10) % 10);
    }
    out[index++] = static_cast<char>('0' + whole % 10);
    out[index++] = '.';
    out[index++] = static_cast<char>('0' + tenths % 10);
    AppendText(out, index, suffix);
    out[index] = '\0';
}

void Format_Int(char *out, const char *prefix, int value, const char *suffix)
{
    int index = 0;
    AppendText(out, index, prefix);
    if (value < 0) {
        out[index++] = '-';
        value = -value;
    }
    if (value >= 100) {
        out[index++] = static_cast<char>('0' + (value / 100) % 10);
    }
    if (value >= 10) {
        out[index++] = static_cast<char>('0' + (value / 10) % 10);
    }
    out[index++] = static_cast<char>('0' + value % 10);
    AppendText(out, index, suffix);
    out[index] = '\0';
}
